# Keil uVision project a.uvprojx, settings and files
target a (6070000::V6.7::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: a
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: STM32F103xB
  c include: Library\inc;User\Inc;CMSIS\inc;Hardware\inc;.cmsis\include;RTE\_Target 1;.eide\deps;FreeRTOS\inc;FreeRTOS\port
  asm define: STM32F103xB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    User/Inc/: FreeRTOSConfig.h
    User/Src/: main.c stm32f1xx_it.c
  group Library
    Library/src/: stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_hal.c stm32f1xx_ll_usb.c
  group Hardware
    Hardware/inc/: adc.h OLED_Font.h SPI.h timer.h USART.h W25Q64.h
    hardware/inc/: IIC.h led.h OLED.h RCC.h
    Hardware/src/: adc.c SPI.c timer.c USART.c W25Q64.c
    hardware/src/: IIC.c led.c OLED.c RCC.c
    ./Hardware/src/: FreeRTOSF.c
    ./Hardware/inc/: FreeRTOSF.h
    ./hardware/src/: key.c
    ./hardware/inc/: key.h
  group FreeRTOS
    FreeRTOS/port/: heap_4.c port.c
    FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group CMSIS
    CMSIS/inc/: stm32f103xb.h
    CMSIS/src/: startup_stm32f103xb.s system_stm32f1xx.c
